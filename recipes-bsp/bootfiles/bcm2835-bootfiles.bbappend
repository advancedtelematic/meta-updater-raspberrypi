RDEPENDS_${PN}_append_sota += " u-boot-bootstrap-script"
